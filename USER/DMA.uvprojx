# Keil uVision project DMA.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_FWLib;..\SYSTEM;..\OBJ;..\USER;..\USMART;..\HARDWARE\DMA;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\adc;..\SYSTEM\can;..\SYSTEM\delay;..\SYSTEM\fun;..\SYSTEM\oled;..\SYSTEM\rgbw;..\SYSTEM\SPI;..\SYSTEM\sys;..\SYSTEM\tim;..\SYSTEM\usart;.\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\OBJ\DMA.sct
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DMA/: dma.c
    ../SYSTEM/tim/: tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/fun/: fun.c
    ../SYSTEM/SPI/: SPI.c
    ../SYSTEM/can/: can.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/oled/: oled.c
    ../SYSTEM/rgbw/: rgbw.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_can.c
software components: CMSIS:CORE 5.2.0
